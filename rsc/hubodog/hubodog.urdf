Commit message: hubodog version updated with urdf fix and tunning

File: rsc/hubodog/hubodog.urdf (robot description, URDF)
Before this commit: robot hubodog_description, 18 links, 17 joints
Links:
- link FR_hip: mass 1.096 -> 2.38674
